PACKAGECONFIG:remove:rpi = "egl glesv2"
